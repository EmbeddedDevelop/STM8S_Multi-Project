<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project1\Project\Project1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Project2\Project\Project2.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Project3\Project\Project3.ewp</path>
    </project>
    <batchBuild />
</workspace>
